# Keil uVision project YSLDV7.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: YSLDV7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\code
  group Source Group 1
    ./: STARTUP.A51
  group CODE
    ./code/: LDChip.c main.c Reg_RW.c
  group user
    ./user/: usart.c
